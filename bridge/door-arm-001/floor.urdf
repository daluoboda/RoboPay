Commit message: fix(door): replace plane with box in floor.urdf

File: bridge/door-arm-001/floor.urdf (robot description, URDF)
Before this commit: robot floor, 1 links, 0 joints
Links:
- link world: geometry collision box size=4 4 0.01; visual box size=4 4 0.01
